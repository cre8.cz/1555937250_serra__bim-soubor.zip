Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-03-17T13:56:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 17 13:56:38 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{DBEA851B-3C97-4121-A075-385B696B2815}\ifc * Database version: 5507 * Database creation date: Thu Mar 17 13:56:38 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 17 13:56:38 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 17 13:56:38 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"), 2015_Table_Viccarbe_Serra-SE50:Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"):129792
In: Nivel 1
Type - ElementType: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Material: Steel lacquered in thermoset epoxy, Lacquered MDF
Type - Identity Data - Bimetica: http://www.bimetica.com/; Content Revision Date: 07/03/2016; Created by: Bimetica Parametric Design Services, S.L.; Description: Sculptural lightweight auxiliary table designed with a strap for easy movement. Ideal for supporting your laptop or simply enjoying a cup of coffee, it comes in multiple finishes to naturally fit into any space. The new round version of our bestseller is now available in the lenght of 50 cm and the height of 50 cm.; General Dimensions (inches): 19.68"x18.89"x19.68"; General Dimensions (mm): 500x480x500mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: HEIGHT 50 WITHOUT BELT; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=20516530db95109; Reference Code: SE50; Series: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-serra-en-11.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Comments: Sculptural lightweight auxiliary table designed with a strap for easy movement. Ideal for supporting your laptop or simply enjoying a cup of coffee, it comes in multiple finishes to naturally fit into any space. The new round version of our bestseller is now available in the lenght of 50 cm and the height of 50 cm.; Type Name: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); URL: http://www.viccarbe.com/; Warranty: 5 Years; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Column Material: Steel lacquered in thermoset epoxy; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf; Table Top Material: Lacquered MDF
Type - Other - Category: Furniture; Depth (mm): 480 mm; Family Name: 2015_Table_Viccarbe_Serra-SE50; Height (mm): 500 mm; Width (mm): 500 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Tipo: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Descripción: Sculptural lightweight auxiliary table designed with a strap for easy movement. Ideal for supporting your laptop or simply enjoying a cup of coffee, it comes in multiple finishes to naturally fit into any space. The new round version of our bestseller is now available in the lenght of 50 cm and the height of 50 cm.; Fabricante: VICCARBE; Modelo: HEIGHT 50 WITHOUT BELT; URL: http://www.viccarbe.com/; Comentarios: Sculptural lightweight auxiliary table designed with a strap for easy movement. Ideal for supporting your laptop or simply enjoying a cup of coffee, it comes in multiple finishes to naturally fit into any space. The new round version of our bestseller is now available in the lenght of 50 cm and the height of 50 cm.
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.432433 m2; Volume: 0.00559902 m3
Other - Family: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Family and Type: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Type: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68"); Type Id: 2015_Table_Viccarbe_Serra-SE50: Serra (SE50) (50x48x50 / 19.68"x18.89"x19.68")
Phasing - Phase Created: Fase 1
